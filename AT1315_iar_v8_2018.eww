<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\AT1315_iar_v8_2018.ewp</path>
    </project>
    <batchBuild />
</workspace>
